File: osw-light.kicad_sch (KiCad schematic)
At the start: 51 parts

Commit message: Autosave
Parts:
- gave numbers to parts that had none: 51
